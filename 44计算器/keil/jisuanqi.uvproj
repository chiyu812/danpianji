# Keil uVision project jisuanqi.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: jisuanqi +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c yanshi.c yanshi.h jvzhenjianpan.c jvzhenjianpan.h LCD1602.c LCD1602.h anjianchuli.c anjianchuli.h cunchu.h yunsuan.c yunsuan.h
